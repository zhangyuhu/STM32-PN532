# Keil uVision project STM32F103RB_FreeRTOS.uvprojx, settings and files
target STM32RBT6 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103RB_FreeRTOS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD  USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport;..\Libraries\CMSIS\DeviceSupport\startup;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\USER;..\USER\app;..\USER\bsp;..\USER\bsp\sys;..\USER\bsp\led;..\USER\bsp\Usart;..\USER\bsp\Log;..\USER\bsp\dwt;..\USER\bsp\delay;..\USER\bsp\DS18B20;..\USER\bsp\RTC;..\USER\test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Code
    ../Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f10x_md.s
  group STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/DeviceSupport/: system_stm32f10x.c
  group FreeRTOS
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group BSP
    ../USER/bsp/sys/: sys.c
    ../USER/bsp/led/: led.c
    ../USER/bsp/Usart/: hal_uart.c
    ../USER/bsp/Log/: log.c
    ../USER/bsp/dwt/: dwt.c
    ../USER/bsp/delay/: delay.c
    ../USER/bsp/DS18B20/: ds18b20.c
    ../USER/bsp/RTC/: rtc.c
  group APP
    ../USER/app/: main.c stm32f10x_it.c
    ../USER/: FreeRTOSConfig.h
  group TEST
    ../USER/test/: app_task.c
